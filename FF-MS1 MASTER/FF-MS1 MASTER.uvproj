# Keil uVision project FF-MS1 MASTER.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: FF-S1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: c8051F020.h c8051F020_SFR16.h STARTUP.A51 FF-MS1.c FF-MS1_Config.c FF-MS1_Config.H FF-MS1_Divers.C FF-MS1_Divers.H
